# Keil uVision project lowr.uvprojx, settings and files
target lowr (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lowr
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M
  c include: ..\USER;..\application;..\boards;..\CORE;..\freertos\include;..\freertos\portable\RVDS\ARM_CM4F;..\HARDWARE\include;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\bmi088;..\HARDWARE\kalman;..\HARDWARE\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FreeRTOS
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
  group SYSTEAM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group HARDWARE
    ../HARDWARE/include/: button.c rm_pid.c tim4_buzzer.c
    ../HARDWARE/bmi088/: BMI088_INT.c BMI088driver.c BMI088Middleware.c ins_task.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/kalman/: kalman_filter.c kalman.c
    ../HARDWARE/lib/: arm_cortexM4lf_math.lib
  group application
    ../application/: chassis_task.c can1_receive.c can1_send.c button_task.c encoder_task.c model_task.c fire_task.c start_task.c pc_task.c
  group boards
    ../boards/: bsp_can1.c rc.c vision.c fire_pwm.c
